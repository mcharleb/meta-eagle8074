KERNEL_SRC_PATH = "/usr/src/${MACHINE}"
PROVIDES += "kernel-eagle8074-devsrc"
RPROVIDES_${PN} += "kernel-eagle8074-devsrc"
