PACKAGECONFIG_remove = "pango"

