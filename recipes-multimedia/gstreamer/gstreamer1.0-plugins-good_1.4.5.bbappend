PACKAGECONFIG_remove = "gdk-pixbuf cairo"
